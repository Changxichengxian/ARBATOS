# Keil uVision project SENTINEL-A.uvprojx, settings and files
target SENTINEL-A (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SENTINEL-A +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ..\..\..\tools\gen_build_info.ps1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../Robotconfig/SENTINEL-A;../../../boards/DJI_A_F427/bsp;../../../boards/DJI_A_F427/devices;../../../shared/hal;../../../shared/components/devices;../../../shared/components/algorithm;../../../shared/components/algorithm/Include;../../../shared/components/controller;../../../shared/components/support;../../../shared/application;../../../shared/application/robot;../../../shared/application/input;../../../shared/application/motors;../../../shared/application/chassis;../../../shared/application/gimbal;../../../shared/application/wheelleg;../../../shared/application/arm;../../../shared/application/shoot;../../../shared/application/comm/can;../../../shared/application/comm/referee;../../../shared/application/comm/host;../../../shared/application/comm/vision;../../../shared/application/services/diagnostics;../../../shared/application/services/storage;../../../shared/application/services/battery;../../../shared/application/services/buzzer;../../../shared/application/services/startup;../../../shared/application/services/servo;../../../shared/application/services/calibration
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Target/SENTINEL-A
    ../../../Robotconfig/SENTINEL-A/: config.c detect_task.c
    ../../../shared/application/input/: control_input.c manual_input.c rc_sbus_task.c
    ../../../shared/application/services/calibration/: pitch_cali.c
    ../../../shared/application/robot/: LowCmd.c robot_lifecycle.c state_store.c control_manager.c
    ../../../shared/application/motors/: motor_model_db.c motor_instance.c can_mit_motor_driver.c
    ../../../shared/application/comm/can/: CAN_receive.c can_feedback_rx_task.c can_command_tx_task.c
    ../../../shared/application/wheelleg/: wheelleg_mit_task.c
    ../../../shared/application/services/diagnostics/: rt_profiler.c watch.c
    ../../../shared/hal/: bsp_can.c bsp_rc.c bsp_key.c bsp_buzzer.c bsp_uart_dispatch.c bsp_pwr.c bsp_shoot_trig.c bsp_dwt.c bsp_time.c bsp_usb.c bsp_imu_pwm.c
    ../../../boards/DJI_A_F427/bsp/: bsp_rc_port.c bsp_referee_port.c diskio.c INS_task.c
    ../../../shared/application/services/storage/: sdcard.c sdlog.c sdlog_task.c
    ../../../shared/components/support/: mem_mang4.c CRC8_CRC16.c
    ../../../shared/components/support/fatfs/: ff.c ffsystem.c ffunicode.c
    ../../../shared/application/comm/host/: host_link_task_stub.c
    ../../../shared/application/chassis/: chassis_behaviour.c chassis_power_control.c chassis_control_task.c
    ../../../shared/application/gimbal/: gimbal_behaviour.c gimbal_control_task.c
    ../../../shared/application/services/buzzer/: buzzer_file_player.c
    ../../../shared/application/comm/referee/: referee.c
    ../../../shared/application/shoot/: shoot.c
    ../../../boards/DJI_A_F427/devices/: mpu6500.c
    ../../../shared/components/algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib kalman_filter.c user_lib.c
    ../../../shared/components/controller/: axis_current_conditioner.c chassis_power_limiter.c gimbal_pid.c pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
