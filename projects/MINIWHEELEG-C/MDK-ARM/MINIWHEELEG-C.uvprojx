# Keil uVision project MINIWHEELEG-C.uvprojx, settings and files
target MINIWHEELEG-C (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: standard_tpye_c +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ..\..\..\tools\gen_build_info.ps1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../Robotconfig/MINIWHEELEG-C;../../../boards/DJI_C_F407/bsp;../../../shared/hal;../../../shared/components/devices;../../../shared/components/algorithm;../../../shared/components/algorithm/Include;../../../shared/components/support;../../../shared/components/controller;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../../../shared/application;../../../shared/application/robot;../../../shared/application/input;../../../shared/application/motors;../../../shared/application/chassis;../../../shared/application/gimbal;../../../shared/application/wheelleg;../../../shared/application/arm;../../../shared/application/shoot;../../../shared/application/comm/can;../../../shared/application/comm/referee;../../../shared/application/comm/host;../../../shared/application/comm/vision;../../../shared/application/services/diagnostics;../../../shared/application/services/storage;../../../shared/application/services/battery;../../../shared/application/services/buzzer;../../../shared/application/services/startup;../../../shared/application/services/servo;../../../shared/application/services/calibration
  asm include: ..\\Core\\Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: MINIWHEELEG-C_ccm.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group boards
    ..//..//..//shared//hal//: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_dwt.c bsp_flash.c bsp_fric.c bsp_imu_pwm.c bsp_i2c.c bsp_led.c bsp_key.c bsp_rc.c bsp_spi.c bsp_usart.c bsp_pwr.c bsp_shoot_trig.c bsp_time.c bsp_usb.c bsp_servo_pwm.c bsp_bmi088_port.c bsp_ist8310_port.c bsp_sd_spi_port.c
    ..//..//..//boards//DJI_C_F407//bsp//: bsp_rc_port.c
  group applications
    ..//..//..//shared//application//services//calibration//: calibrate_task.c pitch_cali.c
    ..//..//..//shared//application//comm//can//: CAN_receive.c can_command_tx_task.c can_feedback_rx_task.c
    ..//..//..//shared//application//robot//: LowCmd.c robot_lifecycle.c state_store.c external_motion_intent.c control_manager.c
    ..//..//..//shared//application//motors//: motor_model_db.c motor_instance.c can_mit_motor_driver.c
    ..//..//..//shared//application//wheelleg//: wheelleg_mit_task.c
    ..//..//..//shared//application//chassis//: chassis_behaviour.c chassis_power_control.c chassis_control_task.c
    ..//..//..//Robotconfig//MINIWHEELEG-C//: detect_task.c config.c
    ..//..//..//shared//application//services//diagnostics//: cpu_usage.c rt_profiler.c watch.c
    ..//..//..//shared//application//gimbal//: gimbal_behaviour.c gimbal_control_task.c
    ..//..//..//boards//DJI_C_F407//bsp//: INS_task.c
    ..//..//..//shared//application//comm//referee//: referee.c referee_rx_task.c
    ..//..//..//shared//application//input//: manual_input.c rc_sbus_task.c elrs_task.c image_remote_link.c control_input.c
    ..//..//..//shared//application//services//buzzer//: buzzer_file_player.c
    ..//..//..//shared//application//shoot//: shoot.c
    ..//..//..//shared//application//services//startup//: startup_service_task.c status_led_task.c
    ..//..//..//shared//application//comm//host//: host_link_task.c aux_port.c aux_tune.c aux_param.c aux_autotune.c aux_telem.c host_tune_bridge.c
    ..//..//..//shared//application//comm//vision//: vision_link.c
    ..//..//..//shared//application//services//battery//: battery_monitor_task.c
    ..//..//..//shared//application//services//servo//: servo_control_task.c
    ..//..//..//shared//application//services//storage//: sdcard.c sdlog.c sdlog_task.c
  group devices
    ..//..//..//shared//components//devices/: BMI088driver.c ist8310driver.c sd_spi.c
  group algorithm
    ..//..//..//shared//components//algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib user_lib.c kalman_filter.c
  group support
    ..//..//..//shared//components//support/: CRC8_CRC16.c fifo.c mem_mang4.c
    ..//..//..//shared//components//support//fatfs//: ff.c ffunicode.c ffsystem.c
    ..//..//..//boards//DJI_C_F407//bsp//: diskio.c
  group controller
    ..//..//..//shared//components//controller/: pid.c pid_advanced.c chassis_power_limiter.c axis_current_conditioner.c gimbal_pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
software components: CMSIS:CORE 4.3.0
