# Keil uVision project INFANTRY-A.uvprojx, settings and files
target INFANTRY-A (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: INFANTRY-A +hex
  BeforeMake: powershell.exe -NoProfile -ExecutionPolicy Bypass -File ..\..\..\tools\GenBuildInfo.ps1
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,IMU_WATCH_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../Robotconfig/INFANTRY-A;../../../boards/DjiAF427/bsp;../../../boards/DjiAF427/devices;../../../shared/hal;../../../shared/components/devices;../../../shared/components/algorithm;../../../shared/components/algorithm/Include;../../../shared/components/controller;../../../shared/components/support;../../../shared/application;../../../shared/application/robot;../../../shared/application/input;../../../shared/application/motors;../../../shared/application/chassis;../../../shared/application/gimbal;../../../shared/application/wheelleg;../../../shared/application/arm;../../../shared/application/shoot;../../../shared/application/comm/can;../../../shared/application/comm/referee;../../../shared/application/comm/host;../../../shared/application/comm/vision;../../../shared/application/services/diagnostics;../../../shared/application/services/storage;../../../shared/application/services/battery;../../../shared/application/services/buzzer;../../../shared/application/services/startup;../../../shared/application/services/servo;../../../shared/application/services/calibration
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Target/INFANTRY-A
    ../../../Robotconfig/INFANTRY-A/: RobotConfig.c DetectTask.c
    ../../../shared/application/input/: ControlInput.c ManualInput.c RcSbusTask.c ElrsTask.c ImageRemoteLink.c
    ../../../shared/application/services/calibration/: PitchCali.c
    ../../../shared/application/robot/: LowCmd.c RobotLifecycle.c StateStore.c FaultMgr.c ExternalMotionIntent.c ControlMgr.c
    ../../../shared/application/motors/: MotorModelDb.c MotorInst.c MotorHealth.c CanMitMotorDriver.c
    ../../../shared/application/comm/can/: CanReceive.c CanRxTask.c CanTxTask.c
    ../../../shared/application/wheelleg/: WheelLegMitTask.c
    ../../../shared/application/services/diagnostics/: RtProf.c Watch.c
    ../../../shared/hal/: BspCan.c BspRc.c BspKey.c BspBuzzer.c BspUartDispatch.c BspPwr.c BspShootTrig.c BspDwt.c BspTime.c BspUsb.c BspImuPwm.c
    ../../../boards/DjiAF427/bsp/: BspUsart.c BspRcPort.c Diskio.c InsTask.c
    ../../../shared/application/services/storage/: SdCard.c SdLog.c SdLogTask.c
    ../../../shared/components/support/: MemMang4.c Crc8Crc16.c
    ../../../shared/components/support/fatfs/: ff.c ffsystem.c ffunicode.c
    ../../../shared/application/comm/host/: HostLinkTask.c AuxPort.c AuxTune.c AuxParam.c AuxAutotune.c AuxTelem.c HostTuneBridge.c
    ../../../shared/application/comm/vision/: VisionLink.c
    ../../../shared/application/chassis/: ChassisBehaviour.c ChassisPowerControl.c ChassisControlTask.c ChassisCtrl.c
    ../../../shared/application/gimbal/: GimbalBehaviour.c GimbalControlTask.c
    ../../../shared/application/services/buzzer/: BuzzerFilePlayer.c
    ../../../shared/application/comm/referee/: Referee.c
    ../../../shared/application/shoot/: Shoot.c ShootCtrl.c
    ../../../boards/DjiAF427/devices/: Mpu6500.c
    ../../../shared/components/algorithm/: AHRS.lib AhrsMiddleware.c arm_cortexM4lf_math.lib KalmanFilter.c UserLib.c
    ../../../shared/components/controller/: AxisCurrentConditioner.c ChassisPowerLimiter.c GimbalPid.c Pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
