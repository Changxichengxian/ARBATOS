# Keil uVision project DM_MIT_TOOL_H7.uvprojx, settings and files
target DM_MIT_TOOL_H7 (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DM_MIT_TOOL_H7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,DM_MIT_TOOL_PROJECT,DM_MIT_TOOL_H7_PROJECT
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../../../shared/common;../../../target/DM_MIT_TOOL_H7/User/application;../../../boards/DM_MC02_H7/app;../../../boards/DM_MC02_H7/bsp;../../../boards/DM_MC02_H7/support;../../../boards/DM_MC02_H7/support/fatfs;../../../shared/bsp/boards;../../../shared/components/devices;../../../shared/components/algorithm;../../../shared/components/controller;../../../shared/components/support;../../../shared/components/support/fatfs;../../../shared/application;../../../shared/application/protocol;../../../shared/components/algorithm/Include
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../../../boards/DM_MC02_H7/app/: board_main.c
    ../Core/Src/: freertos.c gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/DM_MIT_TOOL_H7
    ..//..//..//target//DM_MIT_TOOL_H7//User//application//: config.c mc02_compat.c dm_mit_tool_config.h detect_task.c arm_motor_table.c
    ..//..//..//shared//application//: manual_input.c rc_sbus_task.c control_input.c actuator_cmd.c CAN_receive.c can_feedback_rx_task.c can_command_tx_task.c rt_profiler.c arm_task.c arm_motion.c can_mit_motor_driver.c dm_mit_tool_task.c unitree_motor_driver.c chassis_behaviour.c chassis_power_control.c chassis_control_task.c gimbal_behaviour.c gimbal_control_task.c buzzer_file_player.c shoot.c pitch_cali.c sdcard.c sdlog.c sdlog_task.c host_link_task_stub.c watch.c referee.c referee_rx_task.c cpu_usage.c motor_model_db.c
    ..//..//..//shared//bsp//boards//: bsp_can.c bsp_rc.c bsp_key.c bsp_buzzer.c bsp_laser.c bsp_shoot_trig.c bsp_time.c bsp_dwt.c bsp_imu_pwm.c bsp_bmi088_port.c bsp_delay.c
    ..//..//..//shared//components//devices//: sd_spi.c BMI088driver.c
    ..//..//..//shared//components//support//: mem_mang4.c CRC8_CRC16.c fifo.c
    ..//..//..//shared//components//support//fatfs//: ff.c ffsystem.c ffunicode.c
    ..//..//..//shared//components//controller//: pid.c axis_current_conditioner.c chassis_power_limiter.c gimbal_pid.c
    ../../../boards/DM_MC02_H7/app/: INS_task.c
    ../../../boards/DM_MC02_H7/bsp/: bsp_uart_dispatch.c bsp_usart.c bsp_referee_uart.c bsp_rc_port.c bsp_sd_spi_port.c
    ../../../boards/DM_MC02_H7/support/fatfs/: diskio.c
    ..//..//..//shared//components//algorithm//: user_lib.c kalman_filter.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
