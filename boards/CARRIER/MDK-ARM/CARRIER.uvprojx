# Keil uVision project CARRIER.uvprojx, settings and files
target CARRIER (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CARRIER +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../shared/User/common;../../../target/CARRIER/User/application;../../../target/CARRIER/User/bsp/boards;../../../target/CARRIER/User/components/devices;../../../target/CARRIER/User/components/support;../User/application;../../../shared/User/application/protocol;../User/bsp/boards;../../../shared/User/bsp/boards;../User/components/devices;../../../shared/User/components/devices;../../../shared/User/components/algorithm;../../../shared/User/components/algorithm/Include;../../../shared/User/components/controller;../../../shared/User/components/support;../../../shared/User/application
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/CARRIER
    ../../../target/CARRIER/User/application/: config.c detect_task.c INS_task.c usb_task_stub.c
    ../../../shared/User/application/: app_input.c pitch_cali.c remote_control.c rc_sbus_task.c actuator_cmd.c motor_model_db.c CAN_receive.c can_rx_task.c can_tx_task.c sdcard.c sdlog.c sdlog_task.c chassis_behaviour.c chassis_power_control.c chassis_task.c gimbal_behaviour.c gimbal_task.c buzzer_file_player.c referee.c shoot.c
    ../../../shared/User/bsp/boards/: bsp_can.c bsp_rc.c bsp_key.c bsp_buzzer.c bsp_pwr.c bsp_shoot_trig.c bsp_dwt.c bsp_time.c bsp_usb.c bsp_imu_pwm.c bsp_laser.c
    ../../../target/CARRIER/User/bsp/boards/: bsp_uart_dispatch.c bsp_referee_port.c bsp_rc_port.c
    ../../../shared/User/components/support/: mem_mang4.c CRC8_CRC16.c
    ../../../target/CARRIER/User/components/support/fatfs/: diskio.c
    ../../../shared/User/components/support/fatfs/: ff.c ffsystem.c ffunicode.c
    ../../../target/CARRIER/User/components/devices/: mpu6500.c
    ../../../shared/User/components/algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib kalman_filter.c user_lib.c
    ../../../shared/User/components/controller/: axis_current_conditioner.c chassis_power_limiter.c gimbal_pid.c pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
