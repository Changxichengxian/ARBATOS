# Keil uVision project HERO.uvprojx, settings and files
target HERO (5060960::V5.06 update 7 (build 960)::.\arm compiler5)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: standard_tpye_c +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../../../shared/User/common;../../../target/HERO/User/application;../../../target/HERO/User/bsp/boards;../../../target/HERO/User/components/support;../User/application;../User/bsp/boards;../../../shared/User/bsp/boards;../User/components/devices;../../../shared/User/components/devices;../../../shared/User/components/algorithm;../../../shared/User/components/algorithm/Include;../../../shared/User/components/support;../../../shared/User/application/protocol;../../../shared/User/components/controller;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../../../shared/User/application
  asm include: ..\\Core\\Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: HERO_ccm.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group boards
    ..//..//..//shared//User//bsp//boards//: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_dwt.c bsp_flash.c bsp_fric.c bsp_imu_pwm.c bsp_i2c.c bsp_laser.c bsp_led.c bsp_key.c bsp_rc.c bsp_spi.c bsp_usart.c bsp_pwr.c bsp_shoot_trig.c bsp_time.c bsp_usb.c bsp_servo_pwm.c bsp_bmi088_port.c bsp_ist8310_port.c bsp_sd_spi_port.c
    ..//..//..//target//HERO//User//bsp//boards//: bsp_rc_port.c
  group applications
    ..//..//..//shared//User//application//: calibrate_task.c CAN_receive.c actuator_cmd.c motor_model_db.c can_tx_task.c can_rx_task.c chassis_behaviour.c chassis_power_control.c chassis_task.c cpu_usage.c gimbal_behaviour.c gimbal_task.c pitch_cali.c referee.c referee_usart_task.c remote_control.c rc_sbus_task.c buzzer_file_player.c shoot.c test_task.c elrs_task.c usb_task.c voltage_task.c led_flow_task.c servo_task.c app_input.c app_watch.c sdcard.c sdlog.c sdlog_task.c
    ..//..//..//target//HERO//User//application//: detect_task.c INS_task.c app_config.c
  group devices
    ..//..//..//shared//User//components//devices/: BMI088driver.c ist8310driver.c sd_spi.c
  group algorithm
    ..//..//..//shared//User//components//algorithm/: AHRS.lib AHRS_middleware.c arm_cortexM4lf_math.lib user_lib.c kalman_filter.c
  group support
    ..//..//..//shared//User//components//support/: CRC8_CRC16.c fifo.c mem_mang4.c
    ..//..//..//shared//User//components//support//fatfs//: ff.c ffunicode.c ffsystem.c
    ..//..//..//target//HERO//User//components//support//fatfs//: diskio.c
  group controller
    ..//..//..//shared//User//components//controller/: pid.c pid_advanced.c chassis_power_limiter.c axis_current_conditioner.c gimbal_pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
software components: CMSIS:CORE 4.3.0
